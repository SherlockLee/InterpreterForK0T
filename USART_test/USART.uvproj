# Keil uVision project USART.uvproj, settings and files
target InterpreterForK0T (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: InterpreterForK0T +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\library\inc;..\..\library\src;..\uvsion
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start Up
    ./: STM32F10x.s
  group Source Code
    ./: main.c stm32f10x_it.c
  group library
    ../common/: STM32F10xR.LIB
  group Document
    ./: readme.txt
  group RS274
    ./: rs274ngc_return.h canon.h canon_pre.c rs274ngc.h rs274ngc_pre.c
